# Keil uVision project YANG.uvprojx, settings and files
target YANG (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YANG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1
  c misc: --c99
  c include: ..\File\STM32LIB\CMSIS;..\File\STM32LIB\FWLIB;..\File\API;..\File\BSP;..\File\TASK;..\File\USER;..\File\TYPE;..\File\FreeRTOS\include;..\File\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../File/USER/: main.c main.h global_declare.c global_declare.h stm32f4xx_it.c bsp_init.c bsp_init.h ParamConfig.h FreeRTOSConfig.h
  group API
    ../File/API/: verify.c verify.h gimbal_protocol.c gimbal_protocol.h
  group TASK
    ../File/TASK/: systemmonitor_task.c systemmonitor_task.h led_task.c led_task.h senddata_task.c senddata_task.h communicate_task.c communicate_task.h
  group BSP
    ../File/BSP/: delay.c delay.h systick.c systick.h usart.c usart.h tim.c tim.h led.c led.h
  group TYPE
    ../File/TYPE/: global_types.h os_types.h project_types.h
  group FreeRTOS_CORE
    ../File/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../File/FreeRTOS/portable/MemMang/: heap_4.c
    ../File/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group STM_LIB
    ../File/STM32LIB/CMSIS/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c
    ../File/STM32LIB/CMSIS/Startup/: startup_stm32f40_41xxx.s
    ../File/STM32LIB/FWLIB/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
software components: CMSIS:CORE 5.4.0
